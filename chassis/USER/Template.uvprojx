# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\usart3;..\HARDWARE\usart1;..\HARDWARE\usart2;..\HARDWARE\intconfig;..\HARDWARE\ustdout;..\DEVICE\pms5003;..\HARDWARE;..\DEVICE\gps;..\HARDWARE\timer;..\HARDWARE\led;..\DEVICE;..\HARDWARE\usart_tren;..\HARDWARE\sdio;..\DEVICE\FATFS;..\DEVICE\FATFS\option;..\APP\file;..\DEVICE\ax12;..\APP\file;..\APP\protocal;..\APP;..\HARDWARE\pwm;..\HARDWARE\key;..\DEVICE\jy61;..\HARDWARE\config
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c system_stm32f10x.c stm32f10x_it.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/: hardware.h
    ../HARDWARE/intconfig/: intconfig.c intconfig.h
    ../HARDWARE/ustdout/: ustdout.c ustdout.h
    ../HARDWARE/usart1/: usart1.c usart1.h
    ../HARDWARE/usart2/: usart2.c usart2.h
    ../HARDWARE/usart3/: usart3.c usart3.h
    ../HARDWARE/usart_tren/: usart_tren.c usart_tren.h
    ../HARDWARE/led/: led.c led.h
    ../HARDWARE/timer/: timer.c timer.h
    ../HARDWARE/sdio/: sdio_sdcard.c sdio_sdcard.h
    ../HARDWARE/dma/: dma.c dma.h
    ../HARDWARE/pwm/: pwm.c pwm.h
    ../HARDWARE/key/: key.c key.h
    ../HARDWARE/config/: config.c config.h
    ./: Action.c
  group DEVICE
    ../DEVICE/: device.h
    ../DEVICE/FATFS/: diskio.c ff.c
    ../DEVICE/FATFS/option/: ccsbcs.c
    ../DEVICE/ax12/: ax12.c ax12.h
    ../DEVICE/jy61/: jy61.c jy61.h
  group APP
    ../APP/: app.h
    ../APP/protocal/: protocal.c protocal.h
    ../APP/file/: file.c file.h
